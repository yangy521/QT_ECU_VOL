# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Lib;..\..\Inc;..\..\Kernel;..\..\Main;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: main.c gd32f30x_it.c systick.c
    ../../Apl/: BatteryMeter.c AiProc.c AlarmLampProc.c AngleSensor.c CanRevProc.c LedProc.c MstSlvCom.c Para.c PcuProc.c PressureSensor.c PropProc.c WdgProc.c BeepProc.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Lib_Ecu/: Device.lib
  group Startup
    ../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Lib
    ../../Lib/: IQmathLib.lib
  group USER
    ../../Plc/User/: UserEcuProc.c UserStackerTruckProc.c UserTester.c User4In1.c UserAgvMaxvision.c UserStackerTruckProc_Gangli.c UserStackerTruckProc_Ruyi.c USER_RUYI_CQDH15A.c USER_NUOLI_PS16.c UserHangChaPodaocheProc.c UserStackerTruckProc_JIALI_15TJDC.c UserStackerTruckProc_NUOLI_15Q.c UserForkLiftProc_Chufeng.c User_ForkLiftProc_Liugong.c UserStackerTruckProc_ZJQIANGSHENG.c UserForkLiftXuGong.c USER_GANGLI_PHZ15T.c USER_LIUGONG_FORKLIFT_2IN1.c USER_SDSaiYiSi_2QBICHE.c USER_SDSaiYiSi_LDJCC.c UserStackerTruckProc_SHXIANGONG_AGV.c USER_JIALI_Q20GA.c USER_JIALI_SanZhiLiu.c USER_JIALI_SZDPHZ.c USER_JSKELI_DDTPC.c USER_JSKELI_ZJDQY.c USER_SANYI_DGC.c USER_NBRY_CDD15C.c USER_HANGCHA_DGC.c USER_HANGCHA_PHZ.c USER_RUYI_15A3DGC.c User_CanOpenHangChaApp.c USER_HANGCHA_QYDGC.c USER_GANGLI_20TDGC.c USER_LIDA_20TDGC.c USER_SDBOJUN_20TPHZ.c USER_HANGUO_JINJIDAO_DGC.c User_HANGCHA_GAOJI.c User_HANGUO_JINJIDAO_DBC.c USER_COMM.c User_Demo.c USER_GANGLI_PZDGC.c USER_LIDA_JIANXUANC.c USER_XUGONG_3DC_JCC.c UserForkLiftProcLiuGong.c UserStackerTruckProc_MaXiEr.c UserUds.c
    ../../Plc/: UserCommon.c
  group Doc
    ../: readme.txt
  group Bsp
    ../../Bsp/: DrvAd.c DrvBsp.c DrvCan.c DrvDi.c DrvDo.c DrvPwm.c DrvSpi.c DrvUart.c Drvwdg.c
  group FML
    ../../Fml/: ErrCode.c CanCom.c DoPwm.c Eeprom.c Fml.c HourCount.c Led.c LocalAi.c LocalDi.c LocalDo.c Log.c NetTimer.c PropDriver.c UartCom.c WatchDog.c
  group Canopen
    ../../Lib_Ecu/: Canopen.lib
  group CanopenDriver
    ../../Canopen_drive/src/: STM32_timer_canfestival.c TestSlave.c
target GD32F30X_HD (6180000::V6.18::ARMCLANG)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: as above
  output: USER_RUYI15A3_DGC_ECU_LOGIC_250220_T00 +hex
  AfterMake: D:\InstallFiles\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o ./output/@L.bin ./output/@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Main;..\..\Kernel;..\..\Lib;..\..\Inc;..\;..\..\CanOpen\canfestival\inc;..\..\CanOpen\canfestival\inc\STM32;..\..\CanOpen\can-slave;..\..\CanOpen\objdict;..\..\Canopen_drive\inc;..\..\Inc\UserCan;..\..\Inc\UserLogic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F30X_RELEASE (6180000::V6.18::ARMCLANG)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: as above
  output: LVM4820 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./output/@L.bin ./output/@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,PRJ_RELEASE,WWDG_ENABLE
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Main;..\..\Kernel;..\..\Lib;..\..\Inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F30X_XD (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.5.0
